# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  AfterMake: E:\Work\Duke32\common\pc\win\postbuild.bat E:\Keil_v5\ARM
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_DISCO,DATA_IN_ExtSDRAM,USE_LCD_HDMI,USE_USB_HS,STM32_SDK
  c include: ..\Inc;..\common\STM32F7xx_Driver\Inc;..\common\FatFs\src;..\common\STM32F7xx_Driver\BSP\Components\Common;..\common\STM32F7xx_Driver\BSP\STM32F769I-Discovery;..\common\STM32F7xx_Driver\CMSIS\Device\ST\STM32F7xx\Include;..\common\inc;..\chocolate_duke3D-master\Game\src;..\chocolate_duke3D-master\Engine\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\memsch1.sct
  group Drivers/STM32F7xx_HAL_Driver
    ../common/STM32F7xx_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_jpeg.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_i2s.c stm32f7xx_ll_spi.c stm32f7xx_hal_spi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Option
    ../common/FatFs/src/option/: syscall.c unicode.c
  group Example/MDK-ARM
    ../common/misc/arch/Arm/m7/src/: startup_stm32f769xx.s
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c snd_mem.c snd_mix.c snd_sdl.c sys_sdl.c vid_sdl.c stub.c
    ../common/: mach_stub.c
  group Drivers/BSP/Components
    ../common/STM32F7xx_Driver/BSP/Components/adv7533/: adv7533.c
    ../common/STM32F7xx_Driver/BSP/Components/otm8009a/: otm8009a.c
    ../common/STM32F7xx_Driver/BSP/Components/ft6x06/: ft6x06.c
    ../common/STM32F7xx_Driver/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32F769I_Discovery
    ../common/STM32F7xx_Driver/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c stm32f769i_discovery_audio.c stm32f769i_discovery_qspi.c
  group Middlewares/FatFs/Core
    ../common/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group usbh
    ../common/: usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_ioreq.c usbh_pipes.c
  group common
    ../common/: lcd_main.c input_main.c usb_hid_gamepad.c audio_main.c audio_ext.c audio_mem.c audio_mix.c music_main.c sd_diskio.c dev_main.c heap.c serial.c dev_io.c nvic.c hdmi_mem.c mpu.c
    ../common/misc/arch/Arm/m7/src/: machM7.s asm_utils.s
  group duke32
    ../chocolate_duke3D-master/Game/src/: actors.c animlib.c config.c console.c control.c cvar_defs.c cvars.c dummy_audiolib.c game.c gamedef.c global.c keyboard.c menues.c player.c premap.c rts.c scriplib.c sector.c sounds.c
    ../chocolate_duke3D-master/Engine/src/: cache.c display.c draw.c engine.c filesystem.c fixedPoint_math.c network.c tiles.c mmulti_stable.c
  group audio
    ../chocolate_duke3D-master/Game/src/audiolib/: fx_man.c multivoc.c nodpmi.c dsl.c pitch.c mv_mix.c ll_man.c user.c
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
